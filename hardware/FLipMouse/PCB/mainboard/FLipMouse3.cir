.title KiCad schematic
U1 GNDD +3V3 /E_RESET /FSR3 /FSR4 /PRESSURE /FSR2 /FSR1 /B_0 /BUZZER /B_1 /B_2 /B_PAIR /TSOP GNDD /SDA NC_01 NC_02 NC_03 NC_04 NC_05 NC_06 /SCL /EXT2 /E_P0 NC_07 /ESP_RX /ESP_TX /EXT1 /ESP_SIGNAL NC_08 NC_09 /IR /U_TXD /U_RXD Net-_JP1-Pad1_ NC_10 GNDD GNDD ESP32-WROOM
C2 GNDD /B_2 10n
C1 GNDD /B_1 10n
C18 +3V3 GNDD 10n
C17 +3V3 GNDD 100n
SW1 /B_PAIR GNDD SW_Push
R4 Net-_D3-Pad6_ /B_2 1.5k
R1 Net-_D3-Pad4_ /B_1 1.5k
BZ1 Net-_BZ1-Pad1_ Net-_BZ1-Pad2_ Buzzer
R17 +3V3 Net-_BZ1-Pad1_ 1k5
C6 GND Net-_C6-Pad2_ 18pF
C8 Net-_C8-Pad1_ GND 18pF
C23 +3V3 GND 100n
C22 +3V3 GND 100n
C21 +3V3 GND 10n
C20 +3V3 GND 10n
R12 Net-_C11-Pad2_ GND 1M
R15 Net-_R15-Pad1_ /D- 33R
J9 Net-_D9-Pad3_ /D- /D+ NC_11 GND Net-_C11-Pad2_ USB_OTG
R3 VBUS Net-_J15-Pad1_ 100R
C15 +3V3 GNDD 1u
R16 Net-_R16-Pad1_ /D+ 33R
C11 GND Net-_C11-Pad2_ 10n/500V
C14 VBUS GND 10n
R13 /D+ +3V3 1k5
R2 /JTAG_RESET +3V3 1k5
J10 GNDD Net-_J10-Pad2_ +3V3 /U_TXD /U_RXD Net-_J10-Pad6_ Conn_01x06
Q1 Net-_Q1-Pad1_ Net-_J10-Pad6_ /E_RESET BC847
Q3 Net-_Q3-Pad1_ Net-_J10-Pad2_ /E_P0 BC847
R21 Net-_J10-Pad6_ Net-_Q3-Pad1_ 10k
R19 Net-_J10-Pad2_ Net-_Q1-Pad1_ 10k
C16 +3V3 GNDD 100uF
C13 VBUS GND 1u
C12 VBUS GND 100n
L1 Net-_F1-Pad1_ VBUS WE-74479775147
Q5 /ESP_POWER GND GNDD BSH108
Q2 /BUZZER GNDD Net-_BZ1-Pad2_ BSH108
Y1 Net-_C6-Pad2_ GND Net-_C8-Pad1_ GND JA-12.000-18-DFE
F1 Net-_F1-Pad1_ Net-_D9-Pad3_ MF-NSMF050-2
U3 NC_12 NC_13 /JTAG_RESET Net-_J14-Pad1_ GND Net-_C6-Pad2_ Net-_C8-Pad1_ +3V3 NC_14 NC_15 NC_16 NC_17 NC_18 Net-_J15-Pad1_ /SCL /SDA NC_19 NC_20 Net-_R15-Pad1_ Net-_R16-Pad1_ NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 /ESP_POWER /JTAG_TDO_SWO /JTAG_TCLK_SWCLK NC_27 NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 /JTAG_TMS_SWDIO NC_36 GND NC_37 NC_38 +3V3 /ESP_SIGNAL /ESP_TX /ESP_RX NC_39 LPC11U14FBD
D11 GND /LED1 VBUS /LED2 SK6812
Q6 Net-_JP1-Pad1_ GND /LED1 BSH108
R14 VBUS /LED1 1k5
J14 Net-_J14-Pad1_ tp
J13 /JTAG_RESET tp
J15 Net-_J15-Pad1_ tp
J16 /ESP_TX tp
J17 /ESP_RX tp
D9 /D- GND Net-_D9-Pad3_ Net-_C11-Pad2_ VBUS /D+ IP4220CZ6,125
C19 +3V3 GND 1u
C10 /E_RESET GNDD 1u
R20 /E_RESET +3V3 10k
JP1 Net-_JP1-Pad1_ /LED1 IO direct
SW2 /B_0 GNDD SW_Push
U2 /TSOP GNDD +3V3 TSOP4838
D3 NC_40 GNDD NC_41 Net-_D3-Pad4_ +3V3 Net-_D3-Pad6_ IP4220CZ6,125
U5 NC_42 +3V3 GNDD /PRESSURE NC_43 NC_44 NC_45 NC_46 MPXV7007GP
R5 GNDD /FSR1 10k
R6 GNDD /FSR2 10k
R7 GNDD /FSR3 10k
R8 GNDD /FSR4 10k
U4 VBUS GND +3V3 TSR_1-2433
Q4 /IR GNDD Net-_Q4-Pad3_ BSH108
D4 Net-_D4-Pad1_ VBUS SFH 4244-QR
D6 Net-_D6-Pad1_ Net-_D4-Pad1_ SFH 4244-QR
D7 Net-_D7-Pad1_ Net-_D5-Pad1_ SFH 4244-QR
D5 Net-_D5-Pad1_ VBUS SFH 4244-QR
R9 Net-_D6-Pad1_ Net-_Q4-Pad3_ 22R,min 0.125W
R10 Net-_D7-Pad1_ Net-_Q4-Pad3_ 22R,min 0.125W
R11 /IR GNDD 10k
J5 GNDD +3V3 GND VBUS /SDA /EXT2 /SCL /EXT1 /ESP_RX /ESP_TX Conn_02x05_Odd_Even
J4 +3V3 /JTAG_TMS_SWDIO GND /JTAG_TCLK_SWCLK GND /JTAG_TDO_SWO NC_47 NC_48 GND /JTAG_RESET Conn_ARM_JTAG_SWD_10
R22 /SCL +3V3 10k
R18 /SDA +3V3 10k
J1 Net-_D3-Pad4_ NC_49 GNDD NC_50 PJ320D
J2 Net-_D3-Pad6_ NC_51 GNDD NC_52 PJ320D
J3 +3V3 GNDD VBUS GND /FSR1 /FSR2 /FSR3 /FSR4 /EXT1 /LED2 M50-3900542
Q7 /HALLO /HALLO GND Q_NPN_BCE
.end
